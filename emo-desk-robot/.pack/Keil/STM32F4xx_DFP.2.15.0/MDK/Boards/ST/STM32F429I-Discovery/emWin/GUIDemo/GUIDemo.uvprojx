# Keil uVision project GUIDemo.uvprojx, settings and files
target Debug (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.1-dev14
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: GUIDemo
  c flags: Optim=2 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: HSE_VALUE=8000000 DATA_IN_ExtSDRAM STM32F429I_DISCOVERY
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT6: RAM 0xd0100000 size 0x700000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source
    ./: main.c
    ./: GUIDemo.c
  group Documentation
    ./: Abstract.txt
target Release (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.1-dev14
  cpu: as above
  output: GUIDemo
  c flags: Optim=4 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: HSE_VALUE=8000000 DATA_IN_ExtSDRAM STM32F429I_DISCOVERY
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT6: RAM 0xd0100000 size 0x700000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
software components: CMSIS:CORE 5.4.0, CMSIS:RTOS2:Keil RTX5 5.5.2, CMSIS:RTOS2:Keil RTX5 5.5.2, Compiler:Event Recorder 1.4.0, Board Support:Touchscreen 1.0.0, Board Support:emWin LCD 1.0.0, CMSIS Driver:I2C 2.10, CMSIS Driver:SPI 2.15, Device:STM32Cube Framework:Classic 1.7.9, Device:STM32Cube HAL:Common 1.7.6, Device:STM32Cube HAL:Cortex 1.7.6, Device:STM32Cube HAL:DMA 1.7.6, Device:STM32Cube HAL:DMA2D 1.7.6, Device:STM32Cube HAL:GPIO 1.7.6, Device:STM32Cube HAL:I2C 1.7.6, Device:STM32Cube HAL:LTDC 1.7.6, Device:STM32Cube HAL:PWR 1.7.6, Device:STM32Cube HAL:RCC 1.7.6, Device:STM32Cube HAL:SPI 1.7.6, Device:Startup 2.6.3, Graphics Display:STM32F429I-Discovery 1.0.2, Graphics:CORE 6.10.8, Graphics:Demo:AntialiasedText 6.10.8, Graphics:Demo:Automotive 6.10.8, Graphics:Demo:BarGraph 6.10.8, Graphics:Demo:Bitmap 6.10.8, Graphics:Demo:ColorBar 6.10.8, Graphics:Demo:Cursor 6.10.8, Graphics:Demo:Fading 6.10.8, Graphics:Demo:Framework 6.10.8, Graphics:Demo:Graph 6.10.8, Graphics:Demo:IconView 6.10.8, Graphics:Demo:ListView 6.10.8, Graphics:Demo:RadialMenu 6.10.8, Graphics:Demo:Skinning 6.10.8, Graphics:Demo:Speed 6.10.8, Graphics:Demo:TransparentDialog 6.10.8, Graphics:Demo:Treeview 6.10.8, Graphics:Demo:WashingMachine 6.10.8, Graphics:Input Device:Touchscreen 6.10.8
