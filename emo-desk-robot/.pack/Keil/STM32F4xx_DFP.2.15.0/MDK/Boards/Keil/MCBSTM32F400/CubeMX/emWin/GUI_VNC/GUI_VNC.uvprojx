# Keil uVision project GUI_VNC.uvprojx, settings and files
target Debug (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.1-dev14
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: GUI_VNC
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Files
    ./: GUI_VNC.c GUI_SingleThread.c MyDialogDLG.c
  group Documentation
    ./: Abstract.txt
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32F407IGHx/STCubeGenerated/Src/: main.c stm32f4xx_it.c
    ./RTE/Device/STM32F407IGHx/STCubeGenerated/Inc/: stm32f4xx_it.h
target Release (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.1-dev14
  cpu: as above
  output: GUI_VNC
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
software components: CMSIS:CORE 5.4.0, CMSIS:RTOS2:Keil RTX5 5.5.2, CMSIS:RTOS2:Keil RTX5 5.5.2, Compiler:Event Recorder 1.4.0, Board Support:LED 2.0.0, Board Support:Touchscreen 2.0.0, Board Support:emWin LCD 2.0.0, Network:CORE 7.14.0, Network:CORE 7.14.0, Network:Interface:ETH 7.14.0, Network:Socket:BSD 7.14.0, Network:Socket:TCP 7.14.0, Network:Socket:UDP 7.14.0, CMSIS Driver:Ethernet MAC 2.9, CMSIS Driver:Ethernet PHY:KSZ8081RNA 6.3.0, CMSIS Driver:I2C 2.10, Device:STM32Cube HAL:Common 1.7.9, Device:STM32Cube HAL:Cortex 1.7.9, Device:STM32Cube HAL:DMA 1.7.9, Device:STM32Cube HAL:ETH 1.7.9, Device:STM32Cube HAL:GPIO 1.7.9, Device:STM32Cube HAL:I2C 1.7.9, Device:STM32Cube HAL:PWR 1.7.9, Device:STM32Cube HAL:RCC 1.7.9, Device:STM32Cube HAL:SRAM 1.7.9, Device:Startup 2.6.3, Graphics:CORE 6.10.8, Graphics:Display:MCBQVGA_LG 6.10.8, Graphics:Input Device:Touchscreen 6.10.8, Graphics:Tools:GUI Builder 6.10.8, Graphics:VNC Server 6.10.8
